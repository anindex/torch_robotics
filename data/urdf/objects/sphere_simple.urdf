Commit message: Bullet

File: data/urdf/objects/sphere_simple.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link bottom_plate: geometry collision sphere radius=0.15; visual sphere radius=0.15
